# IAR project prj1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\APP\inc; ..\BSP\inc; ..\DRIVER\CPU\STM8L10x_StdPeriph_Driver\inc; ..\DRIVER\RF\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: prj1.hex
  ILINK.IlinkOutputFile: prj1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/src/: main.c protocol.c stm8l10x_it.c
    ../APP/inc/: stm8l10x_conf.h
  group BSP
    ../BSP/src/: flash.c GPIO.c led.c RF.c spi.c timer.c uart.c
  group DRIVER/CPU
    ../DRIVER/CPU/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_clk.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c
  group DRIVER/RF
    ../DRIVER/RF/src/: CC1101.c
